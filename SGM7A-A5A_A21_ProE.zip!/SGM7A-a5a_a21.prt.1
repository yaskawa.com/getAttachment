# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 4.0 (M220) (file SGM7A-a5a_a21.prt.1)

Parameters:
  PARTNAME = "none"
  CAD_NUMBER = "none"
  PTC_MATERIAL_NAME = "NOVALLOY-S4100"